# Keil uVision project Project.uvprojx, settings and files
target Qi (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\LIBS\startup\arm;..\LIBS\STM32F10x;..\LIBS\STM32F10x_StdPeriph_Driver\inc;..\LIBS\STM32F10x_StdPeriph_Driver\src;..\USER;..\LIBS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: main.c RTC_Time.c
  group Startup
    ../LIBS/startup/arm/: startup_stm32f10x_md.s
  group Libs
    ../LIBS/STM32F10x/: system_stm32f10x.c stm32f10x_it.c
    ../LIBS/STM32F10x_StdPeriph_Driver/src/: stm32f10x_bkp.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c misc.c
